<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NFC06A1_PollingTagDetectNDEF.ewp</path>
  </project>
  <batchBuild />
</workspace>
